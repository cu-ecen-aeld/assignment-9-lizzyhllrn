## base_external/package/aesdchar/Config.in
```kconfig
config BR2_PACKAGE_AESDCHAR
	bool "aesd-char-driver"
	help
	  incldue aesdchar driver
```
